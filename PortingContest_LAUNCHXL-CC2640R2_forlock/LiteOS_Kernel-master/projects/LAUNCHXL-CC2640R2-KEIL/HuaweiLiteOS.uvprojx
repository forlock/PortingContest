# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target LiteOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: CC2640F128 Texas Instruments
  pack: TexasInstruments.CC13xxCC26xx.0.0.2
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: RAM_SIZE_LEVEL_1,LAUNCHXL_CC2640R2
  c include: ..\..\example\include;..\..\kernel\include;..\..\kernel\base\include;..\..\kernel\link\keil;..\..\kernel\cmsis;..\..\kernel\config;..\..\kernel\cpu\arm\cortex-m3;..\..\platform\LAUNCHXL-CC2640R2;..\..\platform\LAUNCHXL-CC2640R2\library\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\platform\LAUNCHXL-CC2640R2\library\cc26x0r2f.sct
  link misc: ..\..\platform\LAUNCHXL-CC2640R2\library\driverlib.lib
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group config
    ../../kernel/config/: los_config.c
  group cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/cc2640r2
    ../../platform/LAUNCHXL-CC2640R2/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group startup
    ../../platform/LAUNCHXL-CC2640R2/library/: ccfg.c startup_keil.s
  group user
    ../../user/: main.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
