# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target LiteOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL26Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.10.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, FRDM_KL26Z, FREEDOM,RAM_SIZE_LEVEL_1
  c include: ..\..\example\include;..\..\kernel\include;..\..\kernel\base\include;..\..\kernel\cmsis;..\..\kernel\config;..\..\kernel\link\keil;..\..\kernel\cpu\arm\cortex-m0;..\..\platform\FRDM-KL26Z;..\..\platform\FRDM-KL26Z\bsp\inc;..\..\platform\FRDM-KL26Z\library;..\..\kernel\link\keil
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group config
    ../../kernel/config/: los_config.c
  group cpu/m0
    ../../kernel/cpu/arm/cortex-m0/: los_dispatch_keil.s los_hw.c los_hw_tick.c los_hwi.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/frdm_kl26z
    ../../platform/FRDM-KL26Z/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group startup
    ../../platform/FRDM-KL26Z/library/: startup_MKL26Z4.s system_MKL26Z4.c
  group user
    ../../user/: main.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
